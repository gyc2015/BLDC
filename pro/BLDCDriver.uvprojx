# Keil uVision project BLDCDriver.uvprojx, settings and files
target BLDCDriver (ARM-ADS)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BLDCDriver
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\lib\stm32_cmsis\inc;..\lib\stm32_periph\inc;..\lib\utils\inc;..\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group stm32_periph
    ../lib/stm32_periph/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group stm32_cmsis
    ../lib/stm32_cmsis/src/: core_cm3.c startup_stm32f10x_ld.s
  group hw
    ../hw/: usart1.c hall.c pwm.c adc.c gpio.c spi1.c
  group app
    ./app/: main.c gVariables.c
  group utils
    ../lib/utils/src/: pid.c queue.c stdio.c utils.c
